# IAR project Project.ewp, settings and files
configuration STM32F4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCDiagSuppress: Pe174
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\qpcpp\include; ..\..\..\qpcpp\ports\arm-cm\qxk\iar; ..\..\..\qpcpp\source; ..\Src\System; ..\Src\UartAct; ..\Src\UartAct\UartOut; ..\Src\UartAct\UartIn; ..\Src\UserBtn; ..\Src\UserLed; ..\Src\WashingMachine; ..\Src\Demo; ..\Src\Traffic; ..\Src\Traffic\Lamp; ..\Src\RobotArm; ..\Src\RobotArm\Motor; ..\Src\TouchBtn
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c stm32f4xx_nucleo.h
  group Drivers/CMSIS/Include
    ../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f401xe.h stm32f4xx.h system_stm32f4xx.h
  group Drivers/STM32F4xx_HAL_Driver/Inc
    ../../../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group Drivers/STM32F4xx_HAL_Driver/Inc/Legacy
    ../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group Drivers/STM32F4xx_HAL_Driver/Src
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_timebase_rtc_alarm_template.c stm32f4xx_hal_timebase_rtc_wakeup_template.c stm32f4xx_hal_timebase_tim_template.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group MyApp/EWARM
    ./: startup_stm32f401xe.s
  group MyApp/Inc
    ../Inc/: bsp.h event.h fw_error.h fw_evt.h fw_log.h fw_macro.h fw_pipe.h hsm_id.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group MyApp/Src
    ../Src/: bsp.cpp event.cpp fw_evt.cpp fw_log.cpp main.cpp stm32f4xx_it.cpp system_stm32f4xx.c
  group MyApp/Src/Demo
    ../Src/Demo/: Demo.cpp Demo.h
  group MyApp/Src/RobotArm
    ../Src/RobotArm/: RobotArm.cpp RobotArm.h RobotArmUserCtrl.cpp RobotArmUserCtrl.h
  group MyApp/Src/RobotArm/Motor
    ../Src/RobotArm/Motor/: Motor.cpp Motor.h
  group MyApp/Src/System
    ../Src/System/: System.cpp System.h Test.cpp Test.h
  group MyApp/Src/TouchBtn
    ../Src/TouchBtn/: TouchBtn.cpp TouchBtn.h
  group MyApp/Src/UartAct
    ../Src/UartAct/: stm32f7xx_hal_uart_msp.cpp UartAct.cpp UartAct.h
  group MyApp/Src/UartAct/UartIn
    ../Src/UartAct/UartIn/: UartIn.cpp UartIn.h
  group MyApp/Src/UartAct/UartOut
    ../Src/UartAct/UartOut/: UartOut.cpp UartOut.h
  group MyApp/Src/UserBtn
    ../Src/UserBtn/: UserBtn.cpp UserBtn.h
  group MyApp/Src/UserLed
    ../Src/UserLed/: LedPattern.cpp LedPattern.h stm32f4xx_hal_pwm_msp.c UserLed.cpp UserLed.h
  group qpcpp/include
    ../../../qpcpp/include/: qassert.h qep.h qequeue.h qf.h qk.h qmpool.h qp_port.h qpcpp.h qpset.h qs.h qs_dummy.h qstamp.cpp qv.h qxk.h qxthread.h
  group qpcpp/ports/arm-cm/qk/gnu
    ../../../qpcpp/ports/arm-cm/qk/gnu/: qep_port.h qf_port.h qk_port.h qk_port.S qs_port.h
  group qpcpp/ports/arm-cm/qk/iar
    ../../../qpcpp/ports/arm-cm/qk/iar/: qep_port.h qf_port.h qk_port.h qk_port.s qs_port.h
  group qpcpp/ports/arm-cm/qxk/gnu
    ../../../qpcpp/ports/arm-cm/qxk/gnu/: qep_port.h qf_port.h qs_port.h qxk_port.h qxk_port.S
  group qpcpp/ports/arm-cm/qxk/iar
    ../../../qpcpp/ports/arm-cm/qxk/iar/: qep_port.h qf_port.h qs_port.h qxk_port.h qxk_port.s
  group qpcpp/source
    ../../../qpcpp/source/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_pkg.h qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp qxk.cpp qxk_mutex.cpp qxk_pkg.h qxk_sema.cpp qxk_xthr.cpp
  group qpcpp/source/Excluded
    ../../../qpcpp/source/Excluded/: qk.cpp qk_mutex.cpp qs.cpp qs_64bit.cpp qs_fp.cpp qs_pkg.h qs_rx.cpp qv.cpp
